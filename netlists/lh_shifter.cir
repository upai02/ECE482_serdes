LH_LevelShifter

.lib '/class/ece482/gpdk045_mos' TT

.TEMP 25.0
.OPTION
+    ARTIST=2
+    INGOLD=2
+    PARHIER=LOCAL
+    PSF=2

c1 vdd vss 12.2025e-18
c2 in vss 55.1353e-18
c3 out vss 14.8269e-18
c4 vddio vss 10.6425e-18
c5 net1 vss 115.728e-18
c6 net2 vss 66.352e-18
c7 n2__net2 vss 37.3945e-18
c8 n2__out vss 36.0014e-18
c9 n3__in vss 42.9203e-18
c10 n2__net1 vss 35.8843e-18
c11 n2__in vss 36.6085e-18
c12 n5__in vss 22.3875e-18
c13 n4__in vss 74.7203e-18
c14 n1__out vss 92.921e-18
c15 n1__in vss 64.5352e-18
c16 n7__out vss 156.785e-18
c17 n8__in vss 162.956e-18
c18 n6__net2 vss 131.24e-18
c19 n5__out vss 204.716e-18
c20 n7__in vss 164.518e-18
c21 n4__net2 vss 109.348e-18
c22 n6__in vss 28.8954e-18
c23 n2__vdd vss 429.994e-18
c24 n1__vdd vss 29.153e-18
c25 n3__net1 vss 46.9857e-18
c26 n1__vddio vss 50.5264e-18
c27 n3__out vss 39.3529e-18
c28 n6__vddio vss 63.6909e-18
c29 n3__net2 vss 36.7e-18
c30 n5__net1 vss 29.95e-18
c31 n2__vddio vss 114.657e-18
c32 n6__out vss 55.722e-18
c33 n5__net2 vss 76.4366e-18
c34 n4__out vss 26.9647e-18
c35 n4__vddio vss 6.51283e-18
c36 n4__net1 vss 115.788e-18
rj1 n4__net2 n6__net2 1.1142
rj2 n8__in n7__in 1.0164
rj3 n7__in n6__in 246.1e-3
rj4 n7__out n5__out 1.3603
rk1 n6__in in 515.7e-3
rk2 n3__net2 n4__net2 31.1625
rk3 n4__net2 n5__net2 37.8974
rk4 n1__in n7__in 549e-3
rk5 n3__out n4__out 31.1718
rk6 n4__out n1__out 257.6e-3
rk7 n4__out n5__out 110.3e-3
rk8 n5__out n6__out 37.7806
rk9 n1__vddio n3__vddio 31.3584
rk10 n3__vddio vddio 255.4e-3
rk11 vddio n4__vddio 93.53e-3
rk13 n4__vddio n6__vddio 31.368
rk14 n2__vddio n3__vddio 75
rk15 n2__vddio n4__vddio 75
rk16 n6__net2 net2 597.2e-3
rk17 n3__net1 n4__net1 62.4505
rk18 n4__net1 net1 668e-3
rk19 n4__net1 n5__net1 75.2648
rk20 n1__vdd n3__vdd 62.3114
rk21 n3__vdd vdd 50.59e-3
rk22 n2__vdd n3__vdd 75
rk23 n1__vss n3__vss 75.3103
rk24 n3__vss vss 576.8e-3
rk25 vss n4__vss 24.83e-3
rk26 n4__vss n5__vss 349e-3
rk28 n4__vss n7__vss 37.868
rk29 n5__vss n8__vss 37.868
rk30 n2__vss n3__vss 62
rk31 n2__vss n4__vss 62
rk32 n2__vss n5__vss 62
rk33 n4__in n8__in 45.5485
rk34 out n7__out 529.7e-3
rl1 n1__out n2__out 62.7771
rl2 n1__in n2__in 62.7771
rl3 net2 n2__net2 62.7771
rl4 net1 n2__net1 62.7771
rl5 n3__in n4__in 258.384
rl6 n4__in n5__in 69.9225
m0 n6__vddio n2__out n3__net2 n2__vddio g45p2svt L=150e-9 W=320e-9 AD=48e-15 AS=48e-15 PD=940e-9 PS=940e-9 NRD=468.75e-3 NRS=468.75e-3 M=1
m1 n1__vddio n2__net2 n3__out n2__vddio g45p2svt L=150e-9 W=320e-9 AD=48e-15 AS=48e-15 PD=940e-9 PS=940e-9 NRD=468.75e-3 NRS=468.75e-3 M=1
mpm0 n1__vdd n3__in n3__net1 n2__vdd g45p1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
m2 n8__vss n2__in n5__net2 n2__vss g45n2svt L=150e-9 W=320e-9 AD=48e-15 AS=48e-15 PD=940e-9 PS=940e-9 NRD=468.75e-3 NRS=468.75e-3 M=1
m3 n7__vss n2__net1 n6__out n2__vss g45n2svt L=150e-9 W=320e-9 AD=48e-15 AS=48e-15 PD=940e-9 PS=940e-9 NRD=468.75e-3 NRS=468.75e-3 M=1
mnm0 n1__vss n5__in n5__net1 n2__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1

** cOUT out VSS 10fF

vVDDIO VDDIO 0 1.8
vVDD VDD 0 1.1
vVSS VSS 0 0
vIN IN 0 pulse( 0 1.1 100ps 100ps 100ps 4n 8n)

.tran 1ps 16ns
.option post
.end
