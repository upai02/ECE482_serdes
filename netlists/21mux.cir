45nm 2:1 MUX
.lib '/class/ece482/gpdk045_mos' TT

c1 vdd vss 20.3533e-18
c2 a vss 30.0559e-18
c3 b vss 30.4624e-18
c4 s vss 44.3379e-18
c5 sbar vss 133.279e-18
c6 z vss 22.6932e-18
c7 n3__sbar vss 22.2136e-18
c8 n1__s vss 23.321e-18
c9 n3__s vss 22.404e-18
c10 n1__sbar vss 22.3303e-18
c11 n2__s vss 16.4377e-18
c12 n2__sbar vss 17.2639e-18
c13 n8__s vss 73.7004e-18
c14 n7__s vss 52.149e-18
c15 n5__s vss 51.6537e-18
c16 n5__sbar vss 114.066e-18
c17 n1__vdd vss 348.646e-18
c18 n2__a vss 34.3194e-18
c19 n1__z vss 33.7096e-18
c20 n6__z vss 31.1205e-18
c21 n2__b vss 37.6247e-18
c22 n1__a vss 33.5746e-18
c23 n5__z vss 32.6199e-18
c24 n4__z vss 34.4767e-18
c25 n1__b vss 39.2423e-18
c26 n2__z vss 36.219e-18
c27 n3__z vss 32.146e-18
ri1 n8__s n7__s 827.2e-3
rj1 n5__s n7__s 500e-3
rj2 sbar n5__sbar 1.3302
rj3 n8__s s 1
rk2 n1__vdd vdd 75
rk3 n2__vss vss 1.894e-3
rk4 n1__vss n2__vss 62
rk5 b n1__b 75.1842
rk6 b n2__b 62.1699
rk7 n5__s n2__s 501.9e-3
rk8 n2__sbar n5__sbar 501.9e-3
rk9 n1__z n2__z 62.18
rk10 n2__z z 206.5e-3
rk11 z n3__z 161.5e-3
rk12 n3__z n4__z 75.1907
rk13 n2__z n5__z 75.1907
rk14 n3__z n6__z 62.18
rk19 a n1__a 75.1735
rk20 a n2__a 62.1806
rl1 n1__s n2__s 91.1338
rl2 n1__sbar n2__sbar 91.1338
rl3 n3__sbar sbar 91.1338
rl4 n3__s s 91.1338
mpm1 n2__a n3__sbar n1__z n1__vdd g45p1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mpm0 n6__z n1__s n2__b n1__vdd g45p1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mnm1 n1__a n3__s n5__z n1__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mnm0 n4__z n1__sbar n1__b n1__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1

vSupply vdd 0 1.1
vGnd vss 0 0
vA a 0 1.1
vB b 0 0
vS s 0 pulse (0 1.1 0 100p 100p 2n 4n)
vSBAR sbar 0 pulse (1.1 0 0 100p 100p 2n 4n)

.tran 1p 16n
.option post

.END
